# Keil uVision project Project_Dynamic_razgruz_L072SU.uvprojx, settings and files
target Project_Dynamic_razgruz_L072SU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project_Dynamic_razgruz_L072SU +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L072xx,USE_HAL_DRIVER
  c include: ../Core/Inc;                                          ../Drivers/STM32L0xx_HAL_Driver/Inc;                                          ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                                          ../Drivers/CMSIS/Include;                                          ..\User;                                          ..\User\Src;                                          ..\User\Inc;                    ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c iwdg.c spi.c tim.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group User
    ../User/Src/: config.c periphery.c bdc_motor.c rs485.c step_motor.c power.c CurrentBDC.c ina239_power.c flash_work.c
software components: CMSIS:CORE 4.3.0
